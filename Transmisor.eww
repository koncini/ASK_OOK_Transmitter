<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Transmisor.ewp</path>
    </project>
    <batchBuild />
</workspace>
